Commit message: fix

File: resources/robots/makZero/urdf/mak-zero.urdf (robot description, URDF)
Before this commit: robot mak-zero, 17 links, 16 joints
Links:
- added link world
Joints:
- added joint floating_base_joint: type floating, parent world, child pelvis
